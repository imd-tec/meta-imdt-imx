SRC_URI = "git://github.com/intel/${BPN};branch="main""