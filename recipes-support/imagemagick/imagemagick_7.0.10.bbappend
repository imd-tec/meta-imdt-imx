SRC_URI = "git://github.com/ImageMagick/ImageMagick.git;branch=main "