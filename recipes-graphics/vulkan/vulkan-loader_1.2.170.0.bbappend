SRC_URI_remove = "git://github.com/KhronosGroup/Vulkan-Loader.git"
SRC_URI_prepend = "git://github.com/KhronosGroup/Vulkan-Loader.git;branch=main " 