SRC_URI_remove = "git://github.com/KhronosGroup/SPIRV-Tools.git"
SRC_URI_prepend = "git://github.com/KhronosGroup/SPIRV-Tools.git;branch=main " 