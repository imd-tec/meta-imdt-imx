SRC_URI_remove = "git://github.com/KhronosGroup/glslang.git;protocol=https"
SRC_URI_prepend = "git://github.com/KhronosGroup/glslang.git;protocol=https;branch=main "