require ../../recipes-connectivity/nxp-wlan-sdk/nxp-wlan-sdk_git_6_1_36.inc
