#
# Copyright (c) 2022 IMD Technologies
#

SRC_URI = "git://github.com/imd-tec/linux-imdt.git;protocol=https;branch=imdt-5.10.72"
SRCREV = "e097a14c9ba02ab6f6600f4cde346386ba39c777"
