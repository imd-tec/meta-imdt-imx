# Removing this package because it does not exist and is breaking the build even though it is listed in the base packagegroup.
QT6_IMAGE_INSTALL_QUICK3D:remove = "qtquick3d-examples"