FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Change-the-audio-format-used-by-the-PDM-test-app.patch"

