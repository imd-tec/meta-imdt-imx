#
# Copyright (c) 2022 IMD Technologies
#

SUMMARY = "U-Boot bootloader provided and supported by IMD Technologies"

SRC_URI = "git://github.com/imd-tec/uboot-imdt.git;protocol=https;branch=imdt-v2021.04"
SRCREV = "b7aa7acce3c8af8ba7fee692a76cfecb672a7341"
